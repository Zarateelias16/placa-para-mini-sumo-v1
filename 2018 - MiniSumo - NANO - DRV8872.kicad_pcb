# Repository Zarateelias16/placa-para-mini-sumo-v1

## KiCad design 2018 - MiniSumo - NANO - DRV8872.kicad_pcb

Board: 2 copper layers, 60.0 x 45.0 mm, 53 parts (16 on the bottom side), 38 nets.

Parts:
BZ1: Buzzer; Pin_Header_2
C1, C4: 10uF; CAP_ELEC_5x11mm
C2, C5: CAPAPOL; CAP_TAN_A
C3, C6, C201, C202: 100nF; C_1206
C7, C8, C9, C11: C; C_1206
C10: CAPAPOL; C_1206
C203: 100uF 35V; CAP_ELEC_10X8mm
D1: 1N4148; SOD80C
D2: LED; LED_1206
ESTRATEGIA: Estrategias; Dip_SW_2-300
ICSP: ICSP; pin_strip_3x2
J3: Izquierdo; Pin_Strip_3
J4: Frontal Izquierdo; Pin_Strip_3
J5: Frontal Derecho; Pin_Strip_3
J6: Derecho; Pin_Strip_3
J7: Bateria; BORNERA2_AZUL
J8: Sensor TATAMI FI; Pin_Strip_3
J9: Sensor TATAMI TI; Pin_Strip_3
J10: Sensor TATAMI TD; Pin_Strip_3
J12: Sensor TATAMI FD; Pin_Strip_3
J202: M2; BORNERA2_AZUL
Q1: 2N7002; SOT23
R1, R2, R8: R; R_1206
R3, R4: 4K7; R_1206
R5, R6: 1K; R_1206
R7: 10K; R_1206
R9, R10: Risen; PTC_1210
SW1: RESET; Pulsador_TH_4
SW2: START; Pulsador_TH_4
U1: LM1117-SOT; SOT223
U2: ATMEGA328P-AU; TQFP-32_7x7mm_Pitch0.8mm
U201, U202: DRV8872; SSOP-8
UART: Transmisor RF; pin_strip_4
VM: M1; BORNERA3_AZUL
Y1: Crystal; HC49S
hole_3mm, hole_3mm#2, hole_3mm#3, hole_3mm#4: VAL**; hole_3mm

Connections:
+5V: C3.1, C4.1, C9.2, C10.1, C11.2, D2.2, ICSP.2, J3.2, J4.2, J5.2, J6.2, J8.2, J9.2, J10.2, J12.2, R1.1, R2.1, R3.1, R4.1, U1.2, U1.4, U2.4, U2.6, U2.18, UART.1
/AUX1: ESTRATEGIA.4, R3.2, U2.1
/AUX2: ESTRATEGIA.3, R4.2, U2.2
/BUZZER: Q1.1, R7.1, U2.9
/C1: C7.2, U2.7, Y1.2
/C2: C8.2, U2.8, Y1.1
/D12/MIS0: ICSP.1, U2.16
/D13/SCK: ICSP.3, R8.1, U2.17
/DISTANCIA_D: J6.3, U2.26
/DISTANCIA_FD: J5.3, U2.25
/DISTANCIA_FI: J4.3, U2.24
/DISTANCIA_I: J3.3, U2.23
/Driver_Motores/VM: C201.1, C202.1, C203.1, U201.5, U202.5, VM.3
/M1A: U2.13, U201.3
/M1B: U2.10, U201.2
/M2A: ICSP.4, U2.15, U202.3
/M2B: U2.14, U202.2
/RESET: C2.1, ICSP.5, R1.2, SW1.3, SW1.4, U2.29
/Rx: R6.1, UART.3
/START: C5.1, R2.2, SW2.3, SW2.4, U2.32
/TATAMI_FD: J12.3, U2.27
/TATAMI_FI: J8.3, U2.28
/TATAMI_TD: J10.3, U2.22
/TATAMI_TI: J9.3, U2.19
/Tx: R5.1, UART.4
/Vin: BZ1.1, C1.1, D1.2, J7.1, U1.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.1, C10.2, C11.1, C201.2, C202.2, C203.2, ESTRATEGIA.1, ESTRATEGIA.2, ICSP.6, J3.1, J4.1, J5.1, J6.1, J7.2, J8.1, J9.1, J10.1, J12.1, Q1.3, R7.2, R9.2, R10.2, SW1.1, SW1.2, SW2.1, SW2.2, U1.1, U2.3, U2.5, U2.21, U201.1, U202.1, UART.2
unnamed: BZ1.2, D1.1, Q1.2
unnamed: C6.1, U2.20
unnamed: D2.1, R8.2
unnamed: U201.8, VM.1
unnamed: U201.6, VM.2
unnamed: J202.1, U202.8
unnamed: J202.2, U202.6
unnamed: R5.2, U2.31
unnamed: R6.2, U2.30
unnamed: R10.1, U201.7
unnamed: R9.1, U202.7
